** Generated for: hspiceD
** Generated on: Dec  4 16:08:32 2022
** Design library name: ECE555
** Design cell name: Multiplexer
** Design view name: schematic
** Cell name: Multiplexer
** View name: schematic
mn1 f s__ b b nmos_rvt w=81e-9 l=20e-9 nfin=3
mn0 f s a a nmos_rvt w=81e-9 l=20e-9 nfin=3
mn5 s__ s vss! vss! nmos_rvt w=81e-9 l=20e-9 nfin=3
mp3 f s b b pmos_rvt w=81e-9 l=20e-9 nfin=3
mp2 f s__ a a pmos_rvt w=81e-9 l=20e-9 nfin=3
mp4 s__ s vdd! vdd! pmos_rvt w=81e-9 l=20e-9 nfin=3
