.INCLUDE "Multiplexer.pex.netlist"

xi0 vss! vdd! s a f b Multiplexer

** Library name: ECE555
** Cell name: MUX_1S_3B
** View name: schematic
xi3 a<2> b<2> f<2> s vdd! vss! Multiplexer
xi2 a<1> b<1> f<1> s vdd! vss! Multiplexer
xi1 a<0> b<0> f<0> s vdd! vss! Multiplexer
